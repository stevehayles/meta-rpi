FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0025-network-online-complete-once-one-link-is-online.patch"